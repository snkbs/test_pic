# Keil uVision project pic.uvprojx, settings and files
target STM32F103CB (ARM-GNU)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: pic +hex
  AfterMake: arm-none-eabi-size.exe -B ./Objects/pic.elf
  AfterMake: arm-none-eabi-objcopy.exe -I ihex -O binary ./Objects/pic.hex pic.bin
  group lib/cm3
    ../libopencm3/lib/cm3/: assert.c dwt.c nvic.c scb.c sync.c systick.c vector.c
  group lib/stm32
    ../libopencm3/lib/stm32/: can.c st_usbfs_v1.c
  group lib/stm32/common
    ../libopencm3/lib/stm32/common/: adc_common_v1.c crc_common_all.c dac_common_all.c dma_common_l1f013.c exti_common_all.c flash_common_all.c flash_common_f.c flash_common_f01.c flash_common_idcache.c gpio_common_all.c i2c_common_v1.c iwdg_common_all.c pwr_common_v1.c rcc_common_all.c spi_common_all.c spi_common_v1.c st_usbfs_core.c timer_common_all.c usart_common_all.c usart_common_f124.c dac_common_v1.c desig_common_all.c desig_common_v1.c dma2d_common_f47.c dsi_common_f47.c
  group lib/stm32/f1
    ../libopencm3/lib/stm32/f1/: adc.c flash.c gpio.c i2c.c rcc.c rtc.c timer.c
  group lib/usb
    ../libopencm3/lib/usb/: usb.c usb_control.c usb_dwc_common.c usb_f107.c usb_lm4f.c usb_msc.c usb_standard.c usb_audio.c usb_cdc.c usb_hid.c usb_midi.c
  group sources
    ./sources/: main.c st.c startup.s startup_helper.c
    ./: stm32f103x8.ld
target STM32F103C8 (ARM-GNU)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: pic +hex
  AfterMake: post_run.cmd pic
